# KOMPAS-3D part (ZARDP 065.040.10.P.m3d)

Model tree:
1. Булева операция:1
2. Булева операция:2
